# Keil uVision project LCD.uvprojx, settings and files
target LCD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: LCD +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../DHT11;../Drivers/SYSTEM/delay;../Drivers/SYSTEM/sys;../MyCode;..\Drivers\HARDWARE\LCD;..\Drivers\HARDWARE\BEEP;..\Drivers\HARDWARE\KEY;..\Drivers\HARDWARE\FALL_DETECT;..\Drivers\HARDWARE\FILTER;..\Drivers\HARDWARE\PMS7003;..\Drivers\HARDWARE\ESP8266
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c fsmc.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c usart.c
  group system
    ../Drivers/SYSTEM/delay/: delay.c
    ../Drivers/SYSTEM/sys/: sys.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group MPU6050
    ../MyCode/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
  group Drivers\HARDWARE\BEEP
    ../Drivers/HARDWARE/BEEP/: beep.c
  group Drivers\HARDWARE\FALL_DETECT
    ../Drivers/HARDWARE/FALL_DETECT/: fall_detect.c
  group Drivers\HARDWARE\FILTER
    ../Drivers/HARDWARE/FILTER/: filter.c
  group Drivers\HARDWARE\KEY
    ../Drivers/HARDWARE/KEY/: key.c
  group Drivers\HARDWARE\PMS7003
    ../Drivers/HARDWARE/PMS7003/: pms7003.c
  group Drivers\HARDWARE\ESP8266
    ../Drivers/HARDWARE/ESP8266/: esp8266.c
  group Drivers\HARDWARE\\LCD
    ../Drivers/HARDWARE/LCD/: lcd.c lcdfont.h
software components: CMSIS:CORE 4.3.0
